# Keil uVision project ppt_154_switch_demo.uvprojx, settings and files
target app (5060960::V5.06 update 7 (build 960)::.\armcc)
  device: ARMCM0P_MPU ARM
  pack: ARM.CMSIS.5.4.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ESEL ELITTLE
  output: app +hex
  BeforeMake: before_build_special.bat
  AfterMake: ..\..\..\..\tool\after_build_common.bat $J #L @L $P $L
  AfterMake: after_build_special.bat
  c flags: Optim=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: CFG_BOARD_RTL8752H,CFG_BT_ADV_EN=0
  c misc: --gnu --preinclude app_define.h --preinclude app_flags.h --preinclude mem_config.h --bss_threshold=0 --diag_suppress=188,546,68
  c include: ..\..\..\..\inc\app;..\..\..\..\inc\bluetooth\gap;..\..\..\..\inc\bluetooth\profile\client;..\..\..\..\inc\bluetooth\profile\server;..\..\..\..\inc\bluetooth\profile;..\..\..\..\inc\os;..\..\..\..\inc\peripheral;..\..\..\..\inc\platform;..\..\..\..\src\app\ppt_driver\common;..\..\..\..\src\app\ppt_driver\simple;..\..\..\..\src\app\ppt_simple_trx;..\..\..\..\subsys\mac_driver;..\..\..\..\subsys\mac_driver\portable\rtl8752h;..\..\..\..\subsys\zb-mac-test\shell;..\..\..\..\subsys\zb-mac-test\test\portable\rtl8752h;..\..\..\..\subsys\zb-mac-test\test\rtk_mac;..\..\..\..\bin\upperstack_img\upperstack_0_0;..\;..\..\..\..\subsys\zb-mac-test\protothread;..\..\..\..\src\app\ppt_154_switch_demo;..\..\..\..\subsys\zb-mac-test\test\portable\common
  asm misc: --cpreproc
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  scatter file: .\app.sct
  link misc: --diag_suppress=L6314,L6312 --datacompressor off
  group include
    ../../../../inc/platform/: rom_uuid.h app_define.h
  group lib
    ../../../../bin/mdk/: ROM.lib lowerstack.lib rtl8752h_sdk.lib zb_ROM.lib libzb_mac_driver.lib
  group cmsis
    ../../../../src/mcu/rtl876x/arm/: startup_rtl876x.s
    ../../../../src/mcu/rtl876x/: system_rtl876x.c
  group platform
    ../../../../src/mcu/peripheral/: rtl876x_nvic.c rtl876x_io_dlps.c rtl876x_rcc.c rtl876x_pinmux.c rtl876x_uart.c
    ../../../../subsys/zb-mac-test/protothread/shell/: pt_cmd_sniffer.c
  group ppt_driver
    ../../../../src/app/ppt_driver/common/: ppt_driver.c
    ../../../../src/app/ppt_driver/simple/: ppt_simple.c
  group zb_driver
    ../../../../subsys/zb-mac-test/shell/: strtol.c strtoll.c strtoul.c strtoull.c cmd_shell.c cmd_shell_rom.c consol_cmds.c shell.c stdio_port.c
    ../../../../subsys/zb-mac-test/test/rtk_mac/: mac_test_common.c mac_test_cmds.c mac_802154_frame_parser.c
    ../../../../subsys/zb-mac-test/test/portable/common/: dbg_printf.c
    ../../../../subsys/zb-mac-test/test/portable/rtl8752h/: platform_port.c
  group app
    ../template/../../../../src/mcu/rtl876x/: overlay_mgr.c
    ../../../../src/app/ppt_154_switch_demo/: main.c app_task.c
  group zb_demo
    ../../../../src/app/ppt_154_switch_demo/zb/: zb_main.c
  group ppt_demo
    ../../../../src/app/ppt_154_switch_demo/ppt/: ppt_cfg.c ppt_ptx.c
  group protothread
    ../../../../subsys/zb-mac-test/protothread/lib/: bitmap.c list.c memb.c ringbuf.c ringbufindex.c
    ../../../../subsys/zb-mac-test/protothread/net/: pt_mac.c
    ../../../../subsys/zb-mac-test/protothread/services/: auto_test.c
    ../../../../subsys/zb-mac-test/protothread/shell/: pt_cmd_ble.c pt_cmd_example.c pt_cmd_mac.c pt_cmd_netconf.c pt_cmd_netstat.c pt_cmd_ping.c pt_cmd_pktgen.c pt_cmd_pktrate.c pt_cmd_rxconf.c pt_cmd_srcmatch.c pt_cmd_sys.c pt_cmd_txconf.c pt_shell.c pt_cmd_sec.c
    ../../../../subsys/zb-mac-test/protothread/sys/: ctimer.c etimer.c process.c timer.c
    ../../../../subsys/zb-mac-test/protothread/transplant_ports/: pt_ports.c
    ../../../../subsys/zb-mac-test/protothread/: protothread.c
