# Keil uVision project template.uvprojx, settings and files
target app (5060750::V5.06 update 6 (build 750)::.\ARMCC_506build750)
  device: ARMCM0P_MPU ARM
  pack: ARM.CMSIS.5.4.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ESEL ELITTLE
  output: app +hex
  BeforeMake: before_build_special.bat
  AfterMake: ..\..\..\..\tool\after_build_common.bat $J #L @L $P $L
  AfterMake: after_build_special.bat
  c flags: Optim=3 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c misc: --gnu --preinclude app_define.h --preinclude mem_config.h --bss_threshold=0
  c include: ..\..\..\..\inc\app;..\..\..\..\inc\bluetooth\gap;..\..\..\..\inc\bluetooth\profile\client;..\..\..\..\inc\bluetooth\profile\server;..\..\..\..\inc\bluetooth\profile;..\..\..\..\inc\os;..\..\..\..\inc\peripheral;..\..\..\..\inc\platform;..\..\..\..\src\app\template;..\..\template
  asm misc: --cpreproc
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  scatter file: .\app.sct
  link misc: --diag_suppress=L6314,L6312 --datacompressor off
  group include
    ../../../../inc/platform/: rom_uuid.h app_define.h
  group lib
    ../../../../bin/mdk/: ROM.lib lowerstack.lib rtl8752h_sdk.lib
  group cmsis
    ../../../../src/mcu/rtl876x/arm/: startup_rtl876x.s
    ../../../../src/mcu/rtl876x/: system_rtl876x.c
  group peripheral
    ../../../../src/mcu/peripheral/: rtl876x_tim.c rtl876x_rcc.c rtl876x_gpio.c rtl876x_uart.c rtl876x_pinmux.c rtl876x_nvic.c rtl876x_io_dlps.c rtl876x_rtc.c rtl876x_lpc.c
  group app
    ../../../../src/app/template/: main.c app_task.c
    ../../../../src/mcu/rtl876x/: overlay_mgr.c
