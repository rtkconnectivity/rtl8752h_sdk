# Keil uVision project project.uvprojx, settings and files
target app (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: ARMCM0P_MPU ARM
  pack: ARM.CMSIS.5.4.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ESEL ELITTLE
  output: app +hex
  BeforeMake: before_build_special.bat
  AfterMake: after_build_common.bat $J #L @L $P $L
  AfterMake: after_build_special.bat
  c flags: Optim=3 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: DRV_LCD_HEIGHT=240, RTK_HAL_DRIVER, RTK_HAL_LCD, ENABLE_RTK_GUI_240_240_DEMO, DRV_PIXEL_BITS=16, ENABLE_HONEYGUI, RTL8752H, DEFINE_RTK_BT_TODO, RTK_HAL_GPIO, DRV_LCD_WIDTH=240
  c misc: --gnu --preinclude app_define.h --preinclude mem_config.h --bss_threshold=0
  c include: ..;..\src;..\src\include;..\src\include\cJSON;..\src\include\gifdec;..\src\include\nanovg;..\src\include\realgui\core;..\src\include\realgui\dc;..\src\include\realgui\engine;..\src\include\realgui\engine\sw;..\src\include\realgui\engine\font;..\src\include\realgui\input;..\src\include\realgui\server;..\src\include\realgui\widget\gui_canvas;..\src\include\realgui\widget\gui_glass;..\src\include\realgui\widget\gui_gray;..\src\include\realgui\widget\gui_img;..\src\include\realgui\widget\gui_list;..\src\include\realgui\widget\gui_lite3d;..\src\include\realgui\widget\gui_menu_cellular;..\src\include\realgui\widget\gui_obj;..\src\include\realgui\widget\gui_qbcode;..\src\include\realgui\widget\gui_soccor;..\src\include\realgui\widget\gui_text;..\src\include\realgui\widget\gui_video;..\src\include\realgui\widget\gui_view;..\src\include\realgui\widget\gui_win;..\..\..\..\..\inc;..\..\..\..\..\inc\app;..\..\..\..\..\inc\peripheral;..\..\..\..\..\inc\platform;..\..\..\..\..\inc\os;..\..\..\..\..\src\inc\peripheral;..\src\gui_port;..\..\..\..\..\src\app\Wearable\audio\music_player;..\..\..\..\..\src\app\Wearable\communicate\rtk_bt;..\..\..\..\..\src\app\Wearable\device\lcd\8752H;..\..\..\..\..\src\app\Wearable\device\lcd\8762G;..\..\..\..\..\src\app\Wearable\device\lcd\8772F;..\..\..\..\..\src\app\Wearable\device\touch\8752H;..\..\..\..\..\src\app\Wearable\device\touch\8762G;..\..\..\..\..\src\app\Wearable\driver\io;..\..\..\..\..\src\app\Wearable\system\clock;..\..\..\..\..\src\app\HoneyGUI\example\application\screen_240_240;..\..\..\..\..\src\app\HoneyGUI\example\widget\glass_effect;..\..\..\..\..\src\app\HoneyGUI\example\widget\glass_effect\root_image
  asm misc: --cpreproc
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  scatter file: .\app.sct
  group app
    ../src/: main.c
  group gui
    ../src/lib/: gui.lib
  group BSP
    ../../../../../bin/mdk/: ROM.lib lowerstack.lib rtl8752h_sdk.lib
    ../../../../../src/mcu/rtl876x/arm/: startup_rtl876x.s
    ../../../../../src/mcu/rtl876x/: system_rtl876x.c overlay_mgr.c
  group peripheral
    ../../../../../src/mcu/peripheral/: rtl876x_pinmux.c rtl876x_rcc.c rtl876x_nvic.c rtl876x_tim.c rtl876x_io_dlps.c rtl876x_gdma.c rtl876x_gpio.c rtl876x_uart.c rtl876x_adc.c rtl876x_spi.c rtl876x_i2c.c rtl876x_rtc.c
  group rtk_gui
    ../src/gui_port/: gui_port_acc.c gui_port_dc.c gui_port_filesystem.c gui_port_ftl.c gui_port_indev.c gui_port_os.c
  group lcd_low_driver
    ../../../../../src/app/Wearable/device/lcd/8752H/: qspi_lcd_platform.c lcd_st77916g5_320_qspi.c
  group hal_drivers
    ../../../../../src/app/Wearable/driver/io/: drv_lcd.c drv_gpio.c
  group realgui/demo
    ../../../../../src/app/HoneyGUI/example/application/screen_240_240/: app_launcher.c
