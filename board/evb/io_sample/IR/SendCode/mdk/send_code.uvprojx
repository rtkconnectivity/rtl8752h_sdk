# Keil uVision project send_code.uvprojx, settings and files
target demo (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: ARMCM0P_MPU ARM
  pack: ARM.CMSIS.5.9.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ESEL ELITTLE
  output: app
  BeforeMake: before_build_special.bat
  AfterMake: ..\..\..\tool\after_build_common.bat $J #L @L $P $L
  c flags: Optim=3 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: SUPPORT_ALONE_UPPERSTACK_IMG
  c misc: --gnu --preinclude app_flags.h --bss_threshold=0
  c include: ..\..\..\..\..\..\bin\upperstack_img\upperstack_0_0;..\..\..\..\..\..\inc\app;..\..\..\..\..\..\inc\bluetooth\gap;..\..\..\..\..\..\inc\bluetooth\gap\gap_lib;..\..\..\..\..\..\inc\bluetooth\profile;..\..\..\..\..\..\inc\bluetooth\profile\client;..\..\..\..\..\..\inc\bluetooth\profile\server;..\..\..\..\..\..\inc\os;..\..\..\..\..\..\inc\peripheral;..\..\..\..\..\..\inc\platform;..\..\..\..\..\..\inc\platform\cmsis;..\..\SendCode;..\..\..\..\..\..\src\sample\io_sample\IR\SendCode;..\..\..\..\..\..\src\sample\io_sample\IR\SendCode\ble_peripheral;..\..\..\..\..\..\src\sample\io_sample\IR\SendCode\config;..\..\..\..\..\..\src\sample\io_sample\IR\SendCode\encode;..\..\..\..\..\..\src\sample\io_sample\IR\SendCode\led;..\..\..\..\..\..\src\sample\io_sample\IR\SendCode\protocol;..\..\..\..\..\..\src\sample\io_sample\IR\SendCode\trans;..\..\..\..\..\..\inc\platform
  asm misc: --cpreproc
  asm include: ..\SendCode
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  scatter file: .\app.sct
  link misc: --diag_suppress=L6314,L6312 --datacompressor off
  group include
    ../../../../../../inc/platform/: app_define.h rom_uuid.h
  group lib
    ../../../../../../bin/mdk/: rtl8752h_sdk.lib gap_utils.lib ROM.lib
  group cmsis
    ../../../../../../src/mcu/rtl876x/: overlay_mgr.c system_rtl876x.c
    ../../../../../../src/mcu/rtl876x/arm/: startup_rtl876x.s
  group peripheral
    ../../../../../../src/mcu/peripheral/: rtl876x_ir.c rtl876x_pinmux.c rtl876x_rcc.c rtl876x_tim.c rtl876x_gpio.c rtl876x_nvic.c
  group profile
    ../../../../../../src/ble/profile/client/: bas_client.c
    ../../../../../../src/ble/profile/server/: bas.c simple_ble_service.c
  group app
    ../../../../../../src/sample/io_sample/IR/SendCode/ble_peripheral/: main.c app_task.c app.c ancs.c
    ../../../../../../src/sample/io_sample/IR/SendCode/: ir_app.c
  group ir_protocol
    ../../../../../../src/sample/io_sample/IR/SendCode/protocol/: dvb_prot.c konica_prot.c lc7464m_prot.c mitc8d8_prot.c nec_prot.c pioneer_prot.c raw_pack_prot.c rc5_prot.c rc6_prot.c sharp_prot.c sony6124_prot.c tc9012_prot.c victorc8d8_prot.c dvb_40bit_prot.c
  group ir_encode
    ../../../../../../src/sample/io_sample/IR/SendCode/encode/: ir_encode.c
  group ir_trans
    ../../../../../../src/sample/io_sample/IR/SendCode/trans/: ir_trans.c
  group ir_led
    ../../../../../../src/sample/io_sample/IR/SendCode/led/: ir_led.c
