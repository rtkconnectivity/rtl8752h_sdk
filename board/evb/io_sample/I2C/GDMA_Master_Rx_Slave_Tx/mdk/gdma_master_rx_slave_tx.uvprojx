# Keil uVision project gdma_master_rx_slave_tx.uvprojx, settings and files
target demo (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: ARMCM0P_MPU ARM
  pack: ARM.CMSIS.5.9.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ESEL ELITTLE
  output: app
  BeforeMake: before_build_special.bat
  AfterMake: ..\..\..\tool\after_build_common.bat $J #L @L $P $L
  c flags: Optim=3 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: SUPPORT_ALONE_UPPERSTACK_IMG
  c misc: --gnu --preinclude mem_config.h  --preinclude app_define.h --bss_threshold=0  --diag_suppress=550  --diag_suppress=186
  c include: ..\..\..\..\..\..\inc\platform;..\..\..\..\..\..\src\mcu\rtl876x;..\..\..\..\..\..\src\mcu\rtl876x\arm;..\..\..\..\..\..\src\mcu\peripheral;..\..\..\..\..\..\inc\peripheral;..\..\..\..\..\..\inc\os;..\..\..\..\..\..\inc\platform\cmsis;..\..\..\..\..\..\inc\app;..\..\..\..\..\..\bin\upperstack_img\upperstack_0_0;..\..\GDMA_Master_Rx_Slave_Tx;..\GDMA_Master_Rx_Slave_Tx
  asm misc: --cpreproc
  asm include: ..\GDMA_Master_Rx_Slave_Tx
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  scatter file: .\app.sct
  link misc: --diag_suppress=L6314,L6312 --datacompressor off
  group include
    ../../../../../../inc/platform/: app_define.h rom_uuid.h
  group lib
    ../../../../../../bin/mdk/: rtl8752h_sdk.lib gap_utils.lib ROM.lib
  group cmsis
    ../../../../../../src/mcu/rtl876x/: overlay_mgr.c system_rtl876x.c
    ../../../../../../src/mcu/rtl876x/arm/: startup_rtl876x.s
  group peripheral
    ../../../../../../src/mcu/peripheral/: rtl876x_i2c.c rtl876x_pinmux.c rtl876x_nvic.c rtl876x_rcc.c rtl876x_gdma.c
  group app
    ../../../../../../src/sample/io_sample/I2C/GDMA_Master_Rx_Slave_Tx/: main.c
