# Keil uVision project adc_continuous.uvprojx, settings and files
target demo (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: ARMCM0P_MPU ARM
  pack: ARM.CMSIS.5.8.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ESEL ELITTLE
  output: app
  BeforeMake: before_build_special.bat
  AfterMake: ..\..\..\tool\after_build_common.bat $J #L @L $P $L
  c flags: Optim=3 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: SUPPORT_ALONE_UPPERSTACK_IMG
  c misc: --gnu --preinclude app_define.h --bss_threshold=0
  c include: ..\..\ContinuousMode;..\..\..\..\..\..\bin\upperstack_img\upperstack_0_0;..\..\..\..\..\..\inc\app;..\..\..\..\..\..\inc\peripheral;..\..\..\..\..\..\inc\platform;..\..\..\..\..\..\inc\platform\cmsis;..\..\..\..\..\..\inc\os;..\..\..\..\..\..\inc\bluetooth\gap;..\..\..\..\..\..\inc\bluetooth\gap\gap_lib;..\..\..\..\..\..\inc\bluetooth\profile;..\..\..\..\..\..\inc\bluetooth\profile\client;..\..\..\..\..\..\inc\bluetooth\profile\server;..\..\..\..\..\..\src\sample\io_sample\ADC\ContinuousMode;..\..\..\..\..\..\src\sample\io_sample\ADC\ContinuousMode\Objects;..\..\..\..\..\..\src\sample\io_sample\ADC\ContinuousMode\ble_peripheral;..\..\..\..\..\..\inc\platform
  asm misc: --cpreproc
  asm include: ..\..\ContinuousMode
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  scatter file: .\app.sct
  link misc: --diag_suppress=L6314,L6312 --datacompressor off
  group include
    ../../../../../../inc/platform/: app_define.h rom_uuid.h
  group lib
    ../../../../../../bin/mdk/: rtl8752h_sdk.lib gap_utils.lib ROM.lib adc.lib
  group cmsis
    ../../../../../../src/mcu/rtl876x/: overlay_mgr.c system_rtl876x.c
    ../../../../../../src/mcu/rtl876x/arm/: startup_rtl876x.s
  group peripheral
    ../../../../../../src/mcu/peripheral/: rtl876x_pinmux.c rtl876x_nvic.c rtl876x_rcc.c rtl876x_adc.c
  group profile
    ../../../../../../src/ble/profile/client/: bas_client.c
    ../../../../../../src/ble/profile/server/: bas.c simple_ble_service.c
  group app
    ../../../../../../src/sample/io_sample/ADC/ContinuousMode/: io_adc.c
    ../../../../../../src/sample/io_sample/ADC/ContinuousMode/ble_peripheral/: ancs.c app.c app_task.c main.c
