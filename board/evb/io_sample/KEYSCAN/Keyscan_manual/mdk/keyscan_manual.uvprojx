# Keil uVision project keyscan_manual.uvprojx, settings and files
target demo (5060750::V5.06 update 6 (build 750)::.\ARMCC_506build750)
  device: ARMCM0P_MPU ARM
  pack: ARM.CMSIS.5.8.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ESEL ELITTLE
  output: app
  BeforeMake: before_build_special.bat
  AfterMake: ..\..\..\tool\after_build_common.bat $J #L @L $P $L
  c flags: Optim=3 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: SUPPORT_ALONE_UPPERSTACK_IMG
  c misc: --gnu --preinclude app_flags.h --bss_threshold=0
  c include: ..\..\..\..\..\..\inc\platform;..\..\..\..\..\..\bin;..\..\..\..\..\..\src\mcu\rtl876x;..\..\..\..\..\..\src\mcu\rtl876x\arm;..\..\..\..\..\..\src\mcu\peripheral;..\..\..\..\..\..\inc\peripheral;..\..\..\..\..\..\inc\bluetooth\profile\server;..\..\..\..\..\..\inc\bluetooth\profile\client;..\..\..\..\..\..\inc\bluetooth\profile;..\..\..\..\..\..\inc\bluetooth\gap\gap_lib;..\..\..\..\..\..\inc\bluetooth\gap;..\..\..\..\..\..\inc\os;..\..\..\..\..\..\inc\platform\cmsis;..\..\..\..\..\..\inc\app;..\..\..\..\..\..\bin\upperstack_img\upperstack_0_0;..\..\Keyscan_manual;..\..\..\..\..\..\src\sample\io_sample\KEYSCAN\Keyscan_Manual;..\..\..\..\..\..\src\sample\io_sample\KEYSCAN\Keyscan_Manual\ble_peripheral
  asm misc: --cpreproc
  asm include: ..\Keyscan_manual
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  scatter file: .\app.sct
  link misc: --diag_suppress=L6314,L6312 --datacompressor off
  group include
    ../../../../../../inc/platform/: app_define.h rom_uuid.h
  group lib
    ../../../../../../bin/mdk/: ROM.lib rtl8752h_sdk.lib gap_utils.lib
  group cmsis
    ../../../../../../src/mcu/rtl876x/: overlay_mgr.c system_rtl876x.c
    ../../../../../../src/mcu/rtl876x/arm/: startup_rtl876x.s
  group peripheral
    ../../../../../../src/mcu/peripheral/: rtl876x_keyscan.c rtl876x_nvic.c rtl876x_pinmux.c rtl876x_rcc.c
  group profile
    ../../../../../../src/ble/profile/client/: ancs_client.c
    ../../../../../../src/ble/profile/server/: bas.c simple_ble_service.c
  group app
    ../../../../../../src/sample/io_sample/KEYSCAN/Keyscan_Manual/: app_timer.c io_keyscan.c
    ../../../../../../src/sample/io_sample/KEYSCAN/Keyscan_Manual/ble_peripheral/: app.c ancs.c app_task.c main.c
