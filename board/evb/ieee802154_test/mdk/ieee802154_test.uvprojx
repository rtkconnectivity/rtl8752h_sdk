# Keil uVision project ieee802154_test.uvprojx, settings and files
target ble_peripheral (5060960::V5.06 update 7 (build 960)::.\armcc)
  device: ARMCM0P_MPU ARM
  pack: ARM.CMSIS.5.9.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ESEL ELITTLE
  output: app +hex
  BeforeMake: before_build_special.bat
  AfterMake: ..\..\..\..\tool\after_build_common.bat $J #L @L $P $L
  AfterMake: after_build_special.bat
  c flags: Optim=3 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: SUPPORT_ALONE_UPPERSTACK_IMG,CFG_BOARD_RTL8752H
  c misc: --gnu --preinclude app_flags.h --preinclude mem_config.h --bss_threshold=0 --diag_suppress=188,546,68
  c include: ..\src;..\..\..\..\inc\bluetooth\gap\gap_lib;..\..\..\..\inc\bluetooth\gap;..\..\..\..\inc\bluetooth\profile;..\..\..\..\inc\app;..\..\ieee802154_test;..\..\..\..\inc\bluetooth\profile;..\..\..\..\inc\bluetooth\profile\server;..\..\..\..\inc\bluetooth\profile\client;..\..\..\..\inc\peripheral;..\..\..\..\inc\platform;..\..\..\..\inc\os;..\..\..\..\inc\os\freertos;..\..\..\..\bin\upperstack_img\upperstack_0_0;..\..\..\..\subsys\mac_driver;..\..\..\..\subsys\mac_driver\portable\rtl8752h;..\..\..\..\subsys\zb-mac-test\shell;..\..\..\..\subsys\zb-mac-test\test\portable\rtl8752h;..\..\..\..\subsys\zb-mac-test\test\rtk_mac;..\..\..\..\subsys\zb-mac-test\protothread;..\..\..\..\subsys\zb-mac-test\test\portable\common
  asm misc: --cpreproc
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  scatter file: .\app.sct
  link misc: --diag_suppress=L6314,L6312 --datacompressor off
  group include
    ../../../../inc/platform/: rom_uuid.h app_define.h
  group lib
    ../../../../bin/mdk/: gap_utils.lib lowerstack.lib rtl8752h_sdk.lib libzb_mac_driver.lib ROM.lib zb_ROM.lib
  group cmsis
    ../../../../src/mcu/rtl876x/arm/: startup_rtl876x.s
    ../../../../src/mcu/rtl876x/: system_rtl876x.c
  group peripheral
    ../../../../src/mcu/peripheral/: rtl876x_io_dlps.c rtl876x_nvic.c rtl876x_pinmux.c rtl876x_rcc.c rtl876x_gpio.c rtl876x_uart.c
  group profile
    ../../../../src/ble/profile/server/: simple_ble_service.c bas.c
    ../../../../src/ble/profile/client/: ancs_client.c
  group app
    ../../../../src/mcu/rtl876x/: overlay_mgr.c
    ../src/: ancs.c app_task.c main.c peripheral_app.c zb_cfg.c
  group shell
    ../../../../subsys/zb-mac-test/shell/: cmd_shell.c cmd_shell_rom.c consol_cmds.c shell.c stdio_port.c strtol.c strtoll.c strtoul.c strtoull.c
  group rtk_mac
    ../../../../subsys/zb-mac-test/test/rtk_mac/: mac_test_cmds.c mac_802154_frame_parser.c mac_test_common.c mac_csl_cmds.c mac_csl_p154.c
    ../../../../subsys/zb-mac-test/test/portable/rtl8752h/: platform_port.c
    ../../../../subsys/zb-mac-test/test/portable/common/: dbg_printf.c zb_main.c
  group protothread
    ../../../../subsys/zb-mac-test/protothread/: protothread.c
    ../../../../subsys/zb-mac-test/protothread/sys/: ctimer.c etimer.c process.c timer.c
    ../../../../subsys/zb-mac-test/protothread/transplant_ports/: pt_ports.c
    ../../../../subsys/zb-mac-test/protothread/shell/: pt_cmd_ble.c pt_cmd_example.c pt_cmd_mac.c pt_cmd_netconf.c pt_cmd_netstat.c pt_cmd_ping.c pt_cmd_pktgen.c pt_cmd_pktrate.c pt_cmd_rxconf.c pt_cmd_srcmatch.c pt_cmd_sys.c pt_cmd_txconf.c pt_shell.c pt_cmd_sniffer.c pt_cmd_sec.c
    ../../../../subsys/zb-mac-test/protothread/net/: pt_mac.c
    ../../../../subsys/zb-mac-test/protothread/lib/: bitmap.c list.c memb.c ringbuf.c ringbufindex.c
    ../../../../subsys/zb-mac-test/protothread/services/: auto_test.c
